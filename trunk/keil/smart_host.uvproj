# Keil uVision project smart_host.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: smart_host +hex
  c flags: Optim=1
  c include: ..\app;..\driver;..\freertos\ARM_CM3;..\freertos\include;..\stm32f10x\inc;..\uip;..\app\test_inc;..\app\telnetd
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group keil
    ./: STM32F10x.s
  group app
    ../app/: main.c FreeRTOSConfig.h stm32f10x_conf.h ParTest.c serial.c
    ../app/test/: BlockQ.c death.c dynamic.c events.c flash.c flop.c integer.c PollQ.c print.c semtest.c timertest.c
  group freertos
    ../freertos/: list.c queue.c tasks.c
    ../freertos/ARM_CM3/: port.c
    ../freertos/MemMang/: heap_2.c
  group uip
    ../uip/: clock_arch.c uip.c uip_arch.c uip_arp.c uip_timer.c
  group stm32f10x
    ../stm32f10x/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim1.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c cortexm3_macro.s
